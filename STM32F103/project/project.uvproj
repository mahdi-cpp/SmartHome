# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c include: ..\source;..\source\code\dataflash;..\source\Library\inc;..\source\Library\src;..\source\code\delay;..\source\code\FATFS\inc;..\source\code\FATFS\src;..\source\code\SD_driver\inc;..\source\code\SD_driver\src;..\source\code\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../source/Library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group code
    ../source/: FatFS_cmds.c RTC_Time.c stm32f10x_it.c
    ../source/code/FATFS/src/: diskio.c ff.c
    ../source/code/SD_driver/src/: SD_driver.c
    ../source/code/Source/: main.c init.c Config.c
    ../source/code/delay/: delay.c
    ../source/code/fuel/: fuel.c
    ../source/code/serial/: Serial.c SerialProcess.c shell.c
    ../source/code/VS1003/: VS1003.c
    ../source/code/MT8888C/: MT8888C.c
    ../source/code/SIM900/: SIM900.c
    ../source/code/ATMEGA8/: ATMEGA8.c
    ../source/code/PhoneService/: PhoneService.c
    ../source/code/PLC/: PLC.c
  group start
    ./Startup/: cortexm3_macro.s stm32f10x_vector.s
    ../source/: stm32f10x_conf.h stm32f10x_it.h
    ../source/code/Source/: Config.h
